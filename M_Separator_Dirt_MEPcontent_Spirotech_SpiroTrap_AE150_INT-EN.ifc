Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_AE150_INT-EN.ifc
Time: 2025-08-05T18:35:16+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2178372_1
Port_2178372_2

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_AE_INT-EN:AE150, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_AE_INT-EN:AE150:2178372
In: F00
Type - Material: Color RGB 168-128-48, Color RGB 168-128-048
Type - Other - Category: Pipe Accessories; Connection Diameter: 38.1 mm; Connection Outer Radius: 24.15 mm; d1: 58.9993 mm; d2: 64.9992 mm; d3: 48.9994 mm; d4: 58.9993 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_AE_INT-EN; h1: 114.999 mm; h2: 30 mm; h3: 12 mm; h4: 55 mm; h5: 78 mm; h6: 198.999 mm; h7: 144.999 mm; h8: 42 mm; Is Visible Body: yes; Is Visible Body 200: no; Is Visible Coupling: no; Is Visible Nut: yes; Is Visible Upper Part: yes; l1: 14.9998 mm; l2: 6 mm; r2: 32.4996 mm; r4: 14.5 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Nominal Diameter: 38.1 mm; Connection Outer Diameter: 48.3 mm; H: 240.997 mm; L: 87.9989 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Particle and dirt separator - Brass 1 1/2"; Article Type: AE150; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Brass 1 1/2"; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811000816; Manufacturer: Spirotech; Manufacturer Art. No.: AE150; Manufacturer URL: https://www.spirotech.com/8717811000816; MEPcontent Class: SEPARATOR_DIRT; Model: AE150; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: AE150; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Brass Yellow: Color RGB 168-128-048
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.0122222 m3/s
Type - Mechanical - Flow - Kv: 0.0122222 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: AE150; sets with these values: 2
Other - Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_AE_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_AE_INT-EN: AE150; Type: AE150; Type Id: 2178351
Constraints - Elevation from Level: 0 mm
Dimensions - Maximum Size: 38.1 mm; Minimum Size: 38.1 mm; Volume: 0.000678748 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
